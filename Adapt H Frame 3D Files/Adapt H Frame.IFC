Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 7045c487-7a0f-4621-b1a9-85218fbc9a67, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates]
File name: HOW Adopt H Frame _ Single screen.ifc
Time: 2026-06-24T08:38:18+10:00
Written by: ODA SDAI 24.11
Made in: Autodesk Revit 25.0.2.419 (ENG) - IFC 25.0.2.419

# IfcProject, 202200
LongName: HOWGROUP; Phase: ADELAIDE

# IfcSite, Default
RefLatitude: 42, 24, 28, 846799; RefLongitude: -71, -15, -9, -709199; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:Level 1, Exhibition
LongName: Exhibition; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Exhibition; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 2029:Generic Models 118, Generic Models 2029:Generic Models 118:430340
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 118; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 2030:Generic Models 6, Generic Models 2030:Generic Models 6:429967
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 6; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 2032:Generic Models 120, Generic Models 2032:Generic Models 120:430352
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 120; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3588:Generic Models 118, Generic Models 3588:Generic Models 118:430371
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 118; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3590:Generic Models 120, Generic Models 3590:Generic Models 120:430383
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 120; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3592:Generic Models 118, Generic Models 3592:Generic Models 118:430286
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 118; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3595:Generic Models 118, Generic Models 3595:Generic Models 118:430308
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 118; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3952:Generic Models 2458, Generic Models 3952:Generic Models 2458:428050
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 2458; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3953:Generic Models 2458, Generic Models 3953:Generic Models 2458:428062
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 2458; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3954:Generic Models 2426, Generic Models 3954:Generic Models 2426:428078
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 2426; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3955:Generic Models 22, Generic Models 3955:Generic Models 22:428088
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 22; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3956:Generic Models 118, Generic Models 3956:Generic Models 118:430392
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 118; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3957:Generic Models 62, Generic Models 3957:Generic Models 62:428104
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3958:Generic Models 62, Generic Models 3958:Generic Models 62:428120
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3959:Generic Models 62, Generic Models 3959:Generic Models 62:428136
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3960:Generic Models 62, Generic Models 3960:Generic Models 62:428152
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3961:Generic Models 62, Generic Models 3961:Generic Models 62:428168
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3962:Generic Models 62, Generic Models 3962:Generic Models 62:428184
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3963:Generic Models 62, Generic Models 3963:Generic Models 62:428200
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3964:Generic Models 62, Generic Models 3964:Generic Models 62:428216
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3965:Generic Models 62, Generic Models 3965:Generic Models 62:428232
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3966:Generic Models 62, Generic Models 3966:Generic Models 62:428248
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3967:Generic Models 62, Generic Models 3967:Generic Models 62:428264
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3968:Generic Models 62, Generic Models 3968:Generic Models 62:428280
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3969:Generic Models 62, Generic Models 3969:Generic Models 62:428296
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3970:Generic Models 62, Generic Models 3970:Generic Models 62:428312
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3971:Generic Models 62, Generic Models 3971:Generic Models 62:428328
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3972:Generic Models 62, Generic Models 3972:Generic Models 62:428344
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3973:Generic Models 96, Generic Models 3973:Generic Models 96:428393
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 96; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3974:Generic Models 96, Generic Models 3974:Generic Models 96:428470
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 96; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3975:Generic Models 22, Generic Models 3975:Generic Models 22:428475
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 22; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3976:Generic Models 118, Generic Models 3976:Generic Models 118:430414
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 118; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3977:Generic Models 62, Generic Models 3977:Generic Models 62:428491
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3978:Generic Models 62, Generic Models 3978:Generic Models 62:428507
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3979:Generic Models 62, Generic Models 3979:Generic Models 62:428523
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3980:Generic Models 62, Generic Models 3980:Generic Models 62:428539
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3981:Generic Models 62, Generic Models 3981:Generic Models 62:428555
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3982:Generic Models 62, Generic Models 3982:Generic Models 62:428571
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3983:Generic Models 62, Generic Models 3983:Generic Models 62:428587
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3984:Generic Models 62, Generic Models 3984:Generic Models 62:428603
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3985:Generic Models 62, Generic Models 3985:Generic Models 62:428619
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3986:Generic Models 62, Generic Models 3986:Generic Models 62:428635
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3987:Generic Models 62, Generic Models 3987:Generic Models 62:428651
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3988:Generic Models 62, Generic Models 3988:Generic Models 62:428667
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3989:Generic Models 62, Generic Models 3989:Generic Models 62:428683
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3990:Generic Models 62, Generic Models 3990:Generic Models 62:428699
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3991:Generic Models 62, Generic Models 3991:Generic Models 62:428715
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3992:Generic Models 62, Generic Models 3992:Generic Models 62:428731
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3993:Generic Models 62, Generic Models 3993:Generic Models 62:428775
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3994:Generic Models 62, Generic Models 3994:Generic Models 62:428791
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3995:Generic Models 22, Generic Models 3995:Generic Models 22:428796
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 22; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3996:Generic Models 62, Generic Models 3996:Generic Models 62:428812
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3997:Generic Models 62, Generic Models 3997:Generic Models 62:428828
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3998:Generic Models 62, Generic Models 3998:Generic Models 62:428844
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 3999:Generic Models 62, Generic Models 3999:Generic Models 62:428860
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4000:Generic Models 62, Generic Models 4000:Generic Models 62:428876
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4001:Generic Models 62, Generic Models 4001:Generic Models 62:428892
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4002:Generic Models 62, Generic Models 4002:Generic Models 62:428908
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4003:Generic Models 62, Generic Models 4003:Generic Models 62:428924
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4004:Generic Models 62, Generic Models 4004:Generic Models 62:428940
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4005:Generic Models 62, Generic Models 4005:Generic Models 62:428956
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4006:Generic Models 62, Generic Models 4006:Generic Models 62:428972
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4007:Generic Models 62, Generic Models 4007:Generic Models 62:428988
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4008:Generic Models 62, Generic Models 4008:Generic Models 62:429004
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4009:Generic Models 62, Generic Models 4009:Generic Models 62:429020
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4010:Generic Models 62, Generic Models 4010:Generic Models 62:429036
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4011:Generic Models 62, Generic Models 4011:Generic Models 62:429052
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4012:Generic Models 62, Generic Models 4012:Generic Models 62:429068
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4013:Generic Models 96, Generic Models 4013:Generic Models 96:429117
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 96; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4014:Generic Models 96, Generic Models 4014:Generic Models 96:429194
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 96; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4015:Generic Models 22, Generic Models 4015:Generic Models 22:429199
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 22; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4016:Generic Models 62, Generic Models 4016:Generic Models 62:429215
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4017:Generic Models 62, Generic Models 4017:Generic Models 62:429231
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4018:Generic Models 62, Generic Models 4018:Generic Models 62:429247
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4019:Generic Models 62, Generic Models 4019:Generic Models 62:429263
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4020:Generic Models 62, Generic Models 4020:Generic Models 62:429279
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4021:Generic Models 62, Generic Models 4021:Generic Models 62:429295
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4022:Generic Models 62, Generic Models 4022:Generic Models 62:429311
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4023:Generic Models 62, Generic Models 4023:Generic Models 62:429327
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4024:Generic Models 62, Generic Models 4024:Generic Models 62:429343
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4025:Generic Models 62, Generic Models 4025:Generic Models 62:429359
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4026:Generic Models 62, Generic Models 4026:Generic Models 62:429375
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4027:Generic Models 62, Generic Models 4027:Generic Models 62:429391
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4028:Generic Models 62, Generic Models 4028:Generic Models 62:429407
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4029:Generic Models 62, Generic Models 4029:Generic Models 62:429423
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4030:Generic Models 62, Generic Models 4030:Generic Models 62:429439
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4031:Generic Models 62, Generic Models 4031:Generic Models 62:429455
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4032:Generic Models 62, Generic Models 4032:Generic Models 62:429471
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4033:Generic Models 62, Generic Models 4033:Generic Models 62:429515
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4034:Generic Models 62, Generic Models 4034:Generic Models 62:429531
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 62; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4035:Generic Models 2431, Generic Models 4035:Generic Models 2431:429539
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 2431; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4036:Generic Models 2434, Generic Models 4036:Generic Models 2434:429565
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 2434; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4037:Generic Models 2431, Generic Models 4037:Generic Models 2431:429577
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 2431; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4038:Generic Models 2431, Generic Models 4038:Generic Models 2431:429589
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 2431; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4039:Generic Models 2430, Generic Models 4039:Generic Models 2430:429608
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 2430; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4040:Generic Models 220, Generic Models 4040:Generic Models 220:429617
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 220; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4041:Generic Models 220, Generic Models 4041:Generic Models 220:429626
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 220; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4042:Generic Models 220, Generic Models 4042:Generic Models 220:429635
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 220; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4043:Generic Models 21, Generic Models 4043:Generic Models 21:429650
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 21; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4044:Generic Models 220, Generic Models 4044:Generic Models 220:429662
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 220; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4045:Generic Models 1065, Generic Models 4045:Generic Models 1065:429674
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 1065; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4046:Generic Models 1, Generic Models 4046:Generic Models 1:429682
In: Exhibition
Type - Material: _Default
Pset_BuildingElementProxyCommon - Reference: Generic Models 1; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4047:Generic Models 1, Generic Models 4047:Generic Models 1:429714
In: Exhibition
Type - Material: _Default
Pset_BuildingElementProxyCommon - Reference: Generic Models 1; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4048:Generic Models 2431, Generic Models 4048:Generic Models 2431:429746
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 2431; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4049:Generic Models 2430, Generic Models 4049:Generic Models 2430:429777
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 2430; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4050:Generic Models 2434, Generic Models 4050:Generic Models 2434:429790
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 2434; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4051:Generic Models 2431, Generic Models 4051:Generic Models 2431:429803
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 2431; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4052:Generic Models 2431, Generic Models 4052:Generic Models 2431:429815
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 2431; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4053:Generic Models 220, Generic Models 4053:Generic Models 220:429824
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 220; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4054:Generic Models 220, Generic Models 4054:Generic Models 220:429833
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 220; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4055:Generic Models 220, Generic Models 4055:Generic Models 220:429842
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 220; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4056:Generic Models 21, Generic Models 4056:Generic Models 21:429857
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 21; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4057:Generic Models 220, Generic Models 4057:Generic Models 220:429869
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 220; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4058:Generic Models 1065, Generic Models 4058:Generic Models 1065:429881
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 1065; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4059:Generic Models 118, Generic Models 4059:Generic Models 118:430446
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 118; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4060:Generic Models 120, Generic Models 4060:Generic Models 120:430458
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 120; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4061:Generic Models 2458, Generic Models 4061:Generic Models 2458:430069
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 2458; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4062:Generic Models 2458, Generic Models 4062:Generic Models 2458:430081
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 2458; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4063:Generic Models 2431, Generic Models 4063:Generic Models 2431:430096
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 2431; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4064:Generic Models 2434, Generic Models 4064:Generic Models 2434:430122
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 2434; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4065:Generic Models 2431, Generic Models 4065:Generic Models 2431:430134
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 2431; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4066:Generic Models 2431, Generic Models 4066:Generic Models 2431:430146
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 2431; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4067:Generic Models 2430, Generic Models 4067:Generic Models 2430:430165
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 2430; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4068:Generic Models 220, Generic Models 4068:Generic Models 220:429890
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 220; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4069:Generic Models 220, Generic Models 4069:Generic Models 220:430174
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 220; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4070:Generic Models 220, Generic Models 4070:Generic Models 220:430183
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 220; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4071:Generic Models 21, Generic Models 4071:Generic Models 21:429905
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 21; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4072:Generic Models 220, Generic Models 4072:Generic Models 220:429917
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 220; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4073:Generic Models 2431, Generic Models 4073:Generic Models 2431:430191
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 2431; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4074:Generic Models 2430, Generic Models 4074:Generic Models 2430:430222
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 2430; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4075:Generic Models 2434, Generic Models 4075:Generic Models 2434:430235
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 2434; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4076:Generic Models 2431, Generic Models 4076:Generic Models 2431:430248
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 2431; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4077:Generic Models 2431, Generic Models 4077:Generic Models 2431:430260
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 2431; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4078:Generic Models 220, Generic Models 4078:Generic Models 220:429926
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 220; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4079:Generic Models 220, Generic Models 4079:Generic Models 220:430269
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 220; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4080:Generic Models 220, Generic Models 4080:Generic Models 220:430278
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 220; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4081:Generic Models 21, Generic Models 4081:Generic Models 21:429941
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 21; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 4082:Generic Models 220, Generic Models 4082:Generic Models 220:429953
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 220; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 5020:Generic Models 118, Generic Models 5020:Generic Models 118:430477
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 118; sets with these values: 2

# IfcBuildingElementProxy: Generic Models 5021:Generic Models 120, Generic Models 5021:Generic Models 120:430489
In: Exhibition
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Generic Models 120; sets with these values: 2
